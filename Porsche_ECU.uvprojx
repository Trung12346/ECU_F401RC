# Keil uVision project Porsche_ECU.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Porsche_ECU
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/core/: main.c
    ./src/hardware/: adc.c core.c dma.c pio.c spi.c tim.c
  group inc
    ./inc/: core_clock_init.h pio_init.h
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
